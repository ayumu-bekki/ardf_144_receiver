# Repository ayumu-bekki/ardf_144_receiver

File README.md:

# ARDF 144MHz Receiver

ESP32-C6ベースの144MHz帯ARDF (Amateur Radio Direction Finding) 用受信機プロジェクトです。
ハードウェアからファームウェア、ケース、アンテナ設計データまでを含んでいます。

## 概要

本プロジェクトはスーパーヘテロダイン方式を採用した144MHz帯ARDF競技用受信機です。
各種制御はXIAO ESP32C6で行い、局部発振器にSi5351Aを使用しています。

### 主な特徴・構成要素
- **XIAO ESP32C6**: メインコントローラ
- **Si5351A**: クロックジェネレータ（局部発振器 LO）
- **MCP4018**: デジタルポテンショメータによる電子ボリューム制御（Aカーブ対応）
- **SSD1306**: 128x32 OLEDディスプレイ搭載（周波数、プリアンプ状態、ボリュームなどを表示）
- カスタムPCB設計 (KiCad)
- 3Dプリント対応専用ケース設計 (FreeCAD / STEP)
- 144MHz帯3エレメント八木・宇田アンテナ設計 (FreeCAD)

## ディレクトリ構成

- `app/ardf_receiver/`: ESP-IDF ファームウェアソースコード (C++17)
- `antenna/`: 144MHz帯3エレメント八木アンテナ設計データ (FreeCAD)
- `case/`: 3Dプリント用ケース設計データ (FreeCAD / STEP)
- `pcb/`: カスタムプリント基板設計データおよびガーバーデータ (KiCad)

## 開発環境 (ファームウェア)

- **フレームワーク**: ESP-IDF (v6.0)
- **言語**: C++17

### ビルドと書き込み

```bash
cd app/ardf_receiver
# ESP-IDF環境のセットアップ (環境に応じて実行)
. $IDF_PATH/export.sh

# ビルド
idf.py build

# デバイスへの書き込みとシリアルモニタの起動
idf.py flash monitor
```

## ライセンス

本プロジェクトは [CERN Open Hardware Licence Version 2 – Permissive (CERN-OHL-P-2.0)](LICENSE) のもとで公開されています。
Copyright (c) 2026 Ayumu Bekki

## KiCad design pcb/ARDFReceiver.kicad_pcb

Parts:
C1: 0.33μ; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C2, C14, C15, C18, C19, C21, C22, C25, C27, C28, C29, C30, C31: 0.1μ; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C3, C4: 10μF; CP_Elec_4x5.8
C5, C7, C8, C16: 1000pF; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C6, C9, C10: 1000p; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C11, C12, C13: 22p; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C17, C20: 0.01μ; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C23: 47μF; CP_Elec_6.3x5.8
C24: 100p; C_0603_1608Metric_Pad1.08x0.95mm_HandSolder
C26: 4.7μF; CP_Elec_4x5.4
F1, F2: LTM455IW (Filter); LTM455IW
H1, H2, H3, H4: MountingHole_3.2mm_M3_Pad_Via
J1: Conn_01x02_MountingPin; JST_PH_B2B-PH-SM4-TB_1x02-1MP_P2.00mm_Vertical
J2: Conn_01x04_MountingPin; JST_PH_B4B-PH-SM4-TB_1x04-1MP_P2.00mm_Vertical
J3: Conn_Coaxial; SMA_S-063-49-TGG_EdgeMount_Horizontal
J4: AudioJack3; Jack_3.5mm_Switronic_ST-005-G_horizontal
JP1: SolderJumper_2_Open; SolderJumper-2_P1.3mm_Open_TrianglePad1.0x1.5mm
L1, L2, L3: 47n; L_0805_2012Metric_Pad1.05x1.20mm_HandSolder
P1: SSD1306 Pin; PinSocket_1x04_P2.54mm_Vertical
Q1, Q3: BSS138; SOT-23-3
Q2: BSS84; SOT-23-3
Q4: 2SC5066-Y; SOT-523_handsold
R1: 200k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R2: 47k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R3, R4: 4.7k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R5, R6, R18, R19: 62; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R7: 270; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R8, R9, R12, R13: 1k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R10, R11, R14, R22, R25, R26: 10k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R15, R20, R23, R24, R27, R28, R29: 100k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R16: 47; R_0603_1608Metric
R17: 240; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R21: 15k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R30: 2.2k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R31: 3.3k; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R32: 47; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R33: 82; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
R34, R35: 100; R_0603_1608Metric_Pad0.98x0.95mm_HandSolder
TP1, TP2: TestPoint; TestPoint_Pad_D1.0mm
U1: XIAO-ESP32-C6; XIAO-ESP32C6-DIP
U2: NJM78L05UA; SOT-89-3_Handsoldering_Thirmo_Via
U3, U4: PE4259; SOT-363_SC-70-6_Handsoldering
U5: Si5351a Module; DIP-8_W7.62mm
U6: NJM2594V (DBM); TSSOP-8_4.4x3mm_P0.65mm
U7: UTC7642; TO-92L_Inline
U8: MCP4018; SOT-363_SC-70-6_Handsoldering
U9: NJM4556AV; TSSOP-8_4.4x3mm_P0.65mm
U10: NJM2125; SOT-23-5_HandSoldering

Connections:
+3.3V: C4.1, C31.1, P1.3, R3.2, R4.2, R8.2, U1.12 (3V3), U5.1, U5.8
+5V: C2.1, C3.1, C14.1, C21.1, C25.1, C27.1, Q2.2 (S), R11.2, R21.1, R23.1, R28.1, U1.14 (VBUS), U2.1 (VO), U6.1, U8.1 (VDD), U9.8 (V+), U10.5 (V+)
+BATT: C1.1, J1.1, R1.2, U2.3 (VI)
Antenna: C5.2, U3.5
AttenuatorIn: R5.2, R7.2, U3.3
AttenuatorOut: R33.1, R35.2, U4.3
AudioSig: C19.1, U8.6 (A)
BatteryVoltage: C18.1, R1.1, R2.2, U1.1 (GPIO0/A0/D0)
Car: C9.2, TP2.1, U6.7
GND: C1.2, C2.2, C3.2, C4.2, C11.1, C12.1, C13.1, C14.2, C17.2, C18.2, C20.2, C21.2, C25.2, C26.2, C27.2, C28.2, C29.1, C30.1, C31.2, F1.3, F1.4, F1.5, F2.3, F2.4, F2.5, H1.1, H2.1, H3.1, H4.1, J1.2, J1.MP (MountPin), J2.4, J2.MP (MountPin), J3.2 (Ext), J4.S, P1.4, Q1.2 (S), Q3.2 (S), Q4.2 (E), R2.1, R5.1, R6.1, R10.2, R14.1, R18.2, R19.2, R24.2, R25.2, R29.2, R34.1, R35.1, U1.13 (GND), U2.2 (GND), U3.2, U4.2, U5.4, U6.4, U7.1, U8.2 (VSS), U9.4 (V-), U10.2 (V-)
IORFSwitch: R9.2, R12.1, U1.7 (GPIO16/D6/TX)
Mix: C15.2, F1.1
unnamed: C7.2, R15.2, R16.1
unnamed: C9.1, R17.1, R18.1
unnamed: C10.1, C11.2, L3.1
unnamed: C10.2, R17.2, R19.1
unnamed: C12.2, L2.1, L3.2
unnamed: C13.2, L1.1, L2.2
unnamed: C23.1, C24.2, R27.2, U9.7
unnamed: C23.2, R25.1, R32.1
unnamed: C26.1, R26.1
unnamed: C28.1, R30.2
unnamed: F1.2, F2.1
unnamed: C6.1, F2.2, R30.1
unnamed: J2.1, U1.11 (GPIO18/D10/MOSI)
unnamed: J2.2, U1.10 (GPIO20/D9/MISO)
unnamed: J2.3, U1.9 (GPIO19/D8/SCK)
unnamed: C5.1, J3.1 (In)
unnamed: J4.R, JP1.1 (A), R32.2
unnamed: J4.T, JP1.2 (B)
unnamed: Q1.3 (D), R8.1, U3.6, U4.6
unnamed: Q1.1 (G), R9.1, R10.1, U3.4, U4.4
unnamed: Q2.3 (D), R13.1
unnamed: Q2.1 (G), Q3.3 (D), R11.1
unnamed: Q3.1 (G), R12.2, R14.2
unnamed: Q4.1 (B), R16.2
unnamed: C8.1, Q4.3 (C), R13.2, R15.1
unnamed: R6.2, R7.1, R33.2, R34.2
unnamed: L1.2, U5.5
unnamed: C15.1, U6.3
unnamed: C16.2, U6.5
unnamed: C17.1, U6.6
unnamed: C6.2, R20.2, U7.2
unnamed: C19.2, C20.1, R20.1, R21.2, R22.2, TP1.1, U7.3
unnamed: C22.1, U8.5 (W)
unnamed: R28.2, R29.1, U9.3 (+)
unnamed: U9.1, U9.2 (-)
unnamed: C22.2, R23.2, R24.1, U9.5 (+)
unnamed: C24.1, R26.2, R27.1, U9.6 (-)
unnamed: R31.2, U10.3 (-), U10.4
RFPreAmpIn: C7.1, U3.1
RFPreAmpOut: C8.2, U4.1
RFSig: C16.1, U4.5
SCL: P1.2, R3.1, U1.6 (GPIO23/D5/SCL), U5.2, U8.3 (SCL)
SDA: P1.1, R4.1, U1.5 (GPIO22/D4/SDA), U5.3, U8.4 (SDA)
SStrengthADC: C30.2, R31.1, U1.2 (GPIO1/A1/D1)
SignalStrengthMeter: C29.2, R22.1, U10.1 (+)

Notes on the sheet:
正弦波生成・LPF
プリアンプ・プリアンプ駆動回路
音声増幅
周波数混合
RFスイッチ
制御用マイコン
OLEDディスプレイ
アンテナ入力
中間周波数BPF・検波
アッテネーター
Sメーター用バッファアンプ
電源・電圧監視

Board: 2 copper layers, 60.0 x 75.0 mm, 97 parts (4 on the bottom side), 57 nets.

## Commit log

2026-03-09 Adjust positions of 3.5mm Jack and Solder Jumper
2026-03-11 Refactor ardf_receiver
2026-03-21 アンテナ3Dデータ追加 CADデータ更新 Sメータ修正
2026-03-22 ケースの追加
2026-03-30 ケースの修正と、ボタンのIO変更
2026-04-04 ボタン制御の修正 esp-idf6.0対応(I2C通信問題対応のため)
2026-04-21 CADデータ更新
2026-05-20 Change license from MIT to Apache License 2.0
2026-05-20 Change license from Apache 2.0 to MIT
2026-05-22 ライセンスをCERN-OHL-P v2 に変更
